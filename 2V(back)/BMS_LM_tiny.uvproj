# Keil uVision project BMS_LM_tiny.uvproj, settings and files
target BMS (MCS-51)
  device: C8051F007 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(20000000)
  output: BMS_2V_75m-V1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_MDK4.7.4\C51\INC\SiLABS;C:\Keil_C51_V5\C51\INC\SiLABS;C:\KeilMDK\C51\INC\SiLABS
  group Source
    ./: Conf_tny.A51 BMS.c libc8051fxxx.LIB
